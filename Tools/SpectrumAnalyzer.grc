options:
  parameters:
    generate_options: qt_gui
    id: SpectrumAnalyzer
    output_language: python
    title: SpectrumAnalyzer
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: '192000'
    step: '1000'
    stop: '56000000'
    value: '3840000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '70000000'
    step: '200000'
    stop: '6000000000'
    value: '102100000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: 'Note: this block is rotated 180 degrees'
    fc: tuning
    fftsize: '1024'
    name: '"Spectrum Analyzer"'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: tuning
    dev_args: '""'
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [qtgui_sink_x_0, freq, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
