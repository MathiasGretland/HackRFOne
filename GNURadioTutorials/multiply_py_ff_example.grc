options:
  parameters:
    generate_options: qt_gui
    id: multiply_py_ff_example
    output_language: python
    title: tutorial_three_2
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: tutorial_multiply_py_ff_0
  id: tutorial_multiply_py_ff
  parameters:
    multiple: '0.333'
  states: {}

connections:
- [analog_sig_source_x_0, '0', tutorial_multiply_py_ff_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [tutorial_multiply_py_ff_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
